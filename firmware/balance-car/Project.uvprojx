# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Libraries;.\Users;.\Systems;.\HardWare
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ./Libraries/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Systems
    ./Systems/: Delay.c Delay.h sys.c sys.h MyFLASH.c MyFLASH.h Store.c Store.h usart.c usart.h
    ../../STM32入门教程资料/程序源码/程序源码/STM32Project-有注释版/12-2 实时时钟/System/: MyRTC.c MyRTC.h
  group HardWare
    ./HardWare/: LED.c LED.h Key.c Key.h Buzzer.c Buzzer.h LightSensors.c LightSensors.h OLED.c OLED.h OLED_Font.h OLED_Data.c OLED_Data.h Ultrasonic.c Ultrasonic.h Motor.c Motor.h PWM.c PWM.h Encoder.c Encoder.h AD.h AD.c Trace.c Trace.h MPU6050.c MPU6050.h MPU6050Reg.c MPU6050Reg.h bsp.c bsp.h ESP8266.c ESP8266.h menu.c menu.h control.c control.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpuiic.c mpuiic.h dmpKey.h dmpmap.h exti.c exti.h
  group Users
    ./Users/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
